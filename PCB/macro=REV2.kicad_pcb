File: PCB/macro=REV2.kicad_pcb (KiCad board)
At the start: 2 copper layers, 102 x 110 mm, 43 parts

Commit message: Stable v0.3
Routing:
- net (no net): track 1980.6 -> 1978.3 mm
